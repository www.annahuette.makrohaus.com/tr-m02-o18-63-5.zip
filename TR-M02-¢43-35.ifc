Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnr.
Time: 2021-03-16T11:23:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.20.44 - Exporter 21.1.20.44 - Alternativ-UI 21.1.20.44
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 16 11:23:35 2021 * Host: NFR0046 * Database: C:\Users\A_GALL~1\AppData\Local\Temp\4bf9be7f-0f16-4d7c-9241-a983e0998028\5558a021-bfb6-4640-8c19-7bfc81101c8c\ifc * Database version: 5507 * Database creation date: Tue Mar 16 11:23:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 16 11:23:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 16 11:23:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnr.
LongName: Bauvorhaben; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 48, 7, 58, 799999; RefLongitude: 11, 34, 58, 799999; RefElevation: 0 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de

# IfcBuilding
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene OKD, Ebene 0
LongName: Ebene 0; Elevation: 5.21586e-13 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene OKD
Grafiken(Type) - Farbe: 16711680; Linienmuster: _Strichpunkt - Mittel; Linienstärke: 1; Symbol: Beschriftung Ebene: Oberkante; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Text - SOFiSTiK_Level: 00
Sonstige - Familie: Ebene: Ebene OKD; Familie und Typ: Ebene: Ebene OKD; Kategorie: Ebenen; Typ: Ebene: Ebene OKD; Typ-ID: Ebene: Ebene OKD
Pset_AirSideSystemInformation - Name: Ebene 0; sets with these values: 2
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no

# IfcMechanicalFastener: M02:M02-ø43/35, M02:M02-ø43/35:1970572: 0
In: Ebene 0
NominalDiameter: 0.262467 m; NominalLength: 0.902231 m
Pset_BuildingElementProxyCommon - Reference: M02:M02-ø43/35; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Konstruktion - Verbindungsmittelnummer: 1
Phasen - Phase erstellt: Phase 1
Satz - Menge: 1
Sonstige - Familie: M02: M02-ø43/35; Familie und Typ: M02: M02-ø43/35; Kategorie: Verbindungsmittel; Typ: M02: M02-ø43/35; Typ-ID: M02: M02-ø43/35

# IfcBuildingElementProxyType, no part of this type: M02:M02-ø43/35
Abmessungen - Außendurchmesser: 0.08 m; Einfassung Stab 1: 0.1 m; Einfassung Stab 2: 0.085 m; Gesamtlänge: 0.275 m; Nenndurchmesser_01 ø: 0.043 m; Nenndurchmesser_02 ø: 0.035 m; TR2040_Sw02: 0.055 m; TR2040-L01: 0.05 m; TR2040-L02: 0.04 m; TR2040-Sw01: 0.07 m; TR3102-d: 0.08 m; TR3102-L: 0.25 m; TR3102-L1: 0.1 m; TR3102-L2: 0.085 m
ID-Daten - Beschreibung: M02-ø43/35; Hersteller: Stahlwerk Annahütte Max Aicher GmbH Co.KG; Modell: M02=TR 3102+TR2040; OmniClass-Nummer: 23.25.10.27.11.21; OmniClass-Titel: Reinforcement Couplers; Typenbild: Rasterbild: M02.png; Typenkommentare: M02-Muffenstoß; Typname: M02-ø43/35; URL: http//:www.annahuette.com
Konstruktion - Endenbearbeitung 1: Endenbearbeitung: Mit Gewinde; Endenbearbeitung 2: Endenbearbeitung: Mit Gewinde; Stabgröße 1: Bewehrungseisen: SAS 670 - ø43; Stabgröße 2: Bewehrungseisen: SAS 670 - ø35
Sonstige - Kategorie: Verbindungsmittel; Familienname: M02; M02_Vis: yes; Pos_TR2040_01: 0.175 m; Pos_TR2040_02: 0.165 m; Pos_TR3102: 0.125 m
Tragwerk - Körper: 5.5 kg; M03-Gewicht: 6.97 kg; TR2040-G01: 1 kg; TR2040-G02: 0.47 kg
Pset_BuildingElementProxyCommon - Reference: M02:M02-ø43/35
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Pset_QuantityTakeOff - Reference: M02:M02-ø43/35
