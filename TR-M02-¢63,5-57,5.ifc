Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnr.
Time: 2021-03-16T11:25:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.20.44 - Exporter 21.1.20.44 - Alternativ-UI 21.1.20.44
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 16 11:25:00 2021 * Host: NFR0046 * Database: C:\Users\A_GALL~1\AppData\Local\Temp\4bf9be7f-0f16-4d7c-9241-a983e0998028\0b3a74d6-c93a-45e1-ac95-c5f45f82bf8a\ifc * Database version: 5507 * Database creation date: Tue Mar 16 11:25:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 16 11:25:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 16 11:25:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnr.
LongName: Bauvorhaben; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 48, 7, 58, 799999; RefLongitude: 11, 34, 58, 799999; RefElevation: 0 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de

# IfcBuilding
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene UKD, UKD Ebene 0
LongName: UKD Ebene 0; Elevation: -0.2 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene UKD
Grafiken(Type) - Farbe: 33023; Linienmuster: _Strichpunkt - Mittel; Linienstärke: 1; Symbol: Beschriftung Ebene: Unterkante; Symbol bei Ende 1 Standard: yes; Symbol bei Ende 2 Standard: no
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Sonstige - Familie: Ebene: Ebene UKD; Familie und Typ: Ebene: Ebene UKD; Kategorie: Ebenen; Typ: Ebene: Ebene UKD; Typ-ID: Ebene: Ebene UKD
ID-Daten - Gebäudegeschoss: yes; Name: UKD Ebene 0; Tragwerk: no
Pset_AirSideSystemInformation - Name: UKD Ebene 0; sets with these values: 2
Abhängigkeiten - Ansicht: -0.2 m
Abmessungen - Höhe für Berechnung: 0 m

# IfcMechanicalFastener: M02:M02-ø63,5/57,5, M02:M02-ø63,5/57,5:1970608: 0
In: UKD Ebene 0
NominalDiameter: 0.360892 m; NominalLength: 1.32874 m
Pset_BuildingElementProxyCommon - Reference: M02:M02-ø63,5/57,5; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Konstruktion - Verbindungsmittelnummer: 1
Phasen - Phase erstellt: Phase 1
Satz - Menge: 1
Sonstige - Familie: M02: M02-ø63,5/57,5; Familie und Typ: M02: M02-ø63,5/57,5; Kategorie: Verbindungsmittel; Typ: M02: M02-ø63,5/57,5; Typ-ID: M02: M02-ø63,5/57,5

# IfcBuildingElementProxyType, no part of this type: M02:M02-ø63,5/57,5
Abmessungen - Außendurchmesser: 0.11 m; Einfassung Stab 1: 0.13 m; Einfassung Stab 2: 0.125 m; Gesamtlänge: 0.405 m; Nenndurchmesser_01 ø: 0.0635 m; Nenndurchmesser_02 ø: 0.0575 m; TR2040_Sw02: 0.09 m; TR2040-L01: 0.07 m; TR2040-L02: 0.06 m; TR2040-Sw01: 0.1 m; TR3102-d: 0.11 m; TR3102-L: 0.305 m; TR3102-L1: 0.13 m; TR3102-L2: 0.125 m
ID-Daten - Beschreibung: M02-ø63,5/57,5; Hersteller: Stahlwerk Annahütte Max Aicher GmbH Co.KG; Modell: M02=TR 3102+TR2040; OmniClass-Nummer: 23.25.10.27.11.21; OmniClass-Titel: Reinforcement Couplers; Typenbild: Rasterbild: M02.png; Typenkommentare: M02-Muffenstoß; Typname: M02-ø63,5/57,5; URL: http//:www.annahuette.com
Konstruktion - Endenbearbeitung 1: Endenbearbeitung: Mit Gewinde; Endenbearbeitung 2: Endenbearbeitung: Mit Gewinde; Stabgröße 1: Bewehrungseisen: SAS 670 - ø63,5; Stabgröße 2: Bewehrungseisen: SAS 670 - ø57,5
Sonstige - Kategorie: Verbindungsmittel; Familienname: M02; M02_Vis: yes; Pos_TR2040_01: 0.2225 m; Pos_TR2040_02: 0.2125 m; Pos_TR3102: 0.1525 m
Tragwerk - Körper: 14.89 kg; M03-Gewicht: 20 kg; TR2040-G01: 3.07 kg; TR2040-G02: 2.04 kg
Pset_BuildingElementProxyCommon - Reference: M02:M02-ø63,5/57,5
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Pset_QuantityTakeOff - Reference: M02:M02-ø63,5/57,5
